# Repository jpulliam/GEM-Kicad

File README.md:

#GEM

KiCad schematics for GEM, a senior design project at the University of Central Florida.

## KiCad design GEM.kicad_pcb

Board: 4 copper layers, 63.5 x 35.6 mm, 14 parts (0 on the bottom side), 25 nets.

Parts:
C18: 2.2n; C_0805_HandSoldering
C19: 10U; C_0805_HandSoldering
C20: 0.1U; C_0805_HandSoldering
D5, D6: LED; LED-0805
JP2: JUMPER3; TESTPOINT3
P1: CONN_01X04; P4
R4: 47k; R_0805_HandSoldering
R15, R16: 330; R_0805_HandSoldering
U11: MSP430F247; LQFP_64PIN_MSP430
U12: RN4020; RN4020_BT
U13: microSD; MicroSD_Slot
U14: JTAG_HEADER; JTAG2X7

Connections:
/BreakoutPin4/3.3V: D5.1, D6.1, JP2.1, P1.4, U12.23, U13.4, U14.4
/BreakoutPin4/GND: C18.1, C19.2, C20.2, P1.3, U11.62, U11.63, U12.1, U12.2, U12.3, U12.4, U12.9, U12.11, U12.13, U12.14, U12.16, U12.18, U12.19, U12.24, U13.6, U14.9
/BreakoutPin4/UART_RX: P1.1, U11.32
/BreakoutPin4/UART_TX: P1.2, U11.33
/JTAG/TCK: U11.57, U14.7
/JTAG/TDI/VPP: U11.55, U14.3
/JTAG/TDO/TDI: U11.54, U14.1
/JTAG/TMS: U11.56, U14.5
/JTAG/VCC/TOOL: C19.1, C20.1, JP2.2, R4.1, U11.1, U11.64
/JTAG/~RST: C18.2, R4.2, U11.58, U14.11
/MSP430F247/CMD: U11.61, U12.8
/MSP430F247/SPI/PIO: U11.3, U12.17
/MSP430F247/SPI_CLK: U11.47, U13.5
/MSP430F247/SPI_SIMO: U11.45, U13.3
/MSP430F247/SPI_SOMI: U11.46, U13.7
/MSP430F247/UART_RX_BT: U11.34, U12.6
/MSP430F247/UART_TX_BT: U11.35, U12.5
/MSP430F247/WAKE_HW: U11.2, U12.15
/MSP430F247/WAKE_SW: U11.60, U12.7
/MSP430F247/~CS: U11.44, U13.2
/RN4020/BT_ACT_LED: R16.2, U12.12
/RN4020/BT_CNT_LED: R15.2, U12.10
unnamed: D5.2, R15.1
unnamed: D6.2, R16.1
unnamed: JP2.3, U14.2

## Commit log

2014-11-09 Initial commit with project outline - TODO: Create parts library and footprints for all non standard parts. Start laying out schematics.
2014-11-09 add readme
2014-11-09 Added STN1110 and MCP2551 to library
2014-11-09 Added datasheets. Schematic design for STN1110 complete TODO: create subsystems for STN1110
2014-11-09 STN1110 schematic layout complete
2014-11-09 Created hierarchical scheme for schematics TODO: Change power ports to hierarchical pins
2014-11-09 Added power ports to STN1110
2014-11-11 Added MCP2551 and it's connections to STN1110
2014-11-15 Added status lights sheet
2014-11-15 Added transceivers for J1850 and ISO
2014-11-15 Added transceivers, power and voltage sense. Updated connections between complete sub groups with busses.
2014-11-15 Updated project with plot command
2014-11-16 Added header for breakout board
2014-11-16 Added MSP430
    Added MSP430F247 to library and placed in a new hierarchical sheet.
2014-11-17 Added Bluetooth module and SD card
    Added RN4020 and a microSD card to libraries, connected most pins. Also
    added datasheets.
2014-11-21 Finish Schematics
    Finish connections, including unused pins. Some doubts on certain
    electrical connections.
2014-11-23 Added JTAG interface
    Spy Bi-Wire JTAG interface. Fixed some unused pins.
2014-11-23 Linked components to footprints, may have to switch to smaller components. Started board layout.
2014-11-26 General fine tuning of schematics. Need to review JTAG and update. Added resistors to power stage. Getting prepped for BOM, need to go through item by item. Added current incomplete BOM
2015-01-19 Setting up for footprints
    Attempting to add footprint library.
2015-01-19 Footprints
    Take 2 on setting up the folder structure to work on footprints.
2015-01-19 Updated parts and data sheets
2015-01-21 Added footprints
2015-01-23 Updated power supply removing a short. Updated resistor values for LED's after finding what LED's are available in 0805 size.
2015-02-03 1st Revision
    Complete Board layout, 1st Draft
2015-02-06 Fixed transceiver error
